# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: ..\Libraries\CMSIS\GD\GD32F10x\Include;..\Libraries\CMSIS;..\Libraries\GD32F10x_standard_peripheral\Include;..\User;..\User\BSP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c
  group BSP
    ../User/BSP/: gd32f10x_it.c systick.c run_led.c
  group MDK-ARM
    ../Libraries/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group HAL_Driver
    ../Libraries/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group CMSIS
    ../Libraries/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
